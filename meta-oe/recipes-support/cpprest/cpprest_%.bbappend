FILESEXTRAPATHS_append := "${THISDIR}/files:"

SRC_URI_append = " file://0001-Fix-openssl-libcrypto-issue.patch"
