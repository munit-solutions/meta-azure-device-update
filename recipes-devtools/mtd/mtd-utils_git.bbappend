SRC_URI_remove += "file://0001-mtd-utils-Fix-return-value-of-ubiformat.patch"
